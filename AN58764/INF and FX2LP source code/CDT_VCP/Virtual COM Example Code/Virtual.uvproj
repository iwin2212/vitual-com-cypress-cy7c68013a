# Keil uVision project Virtual.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: VirtualCom +hex
  AfterMake: .\hex2bix -i -f 0xC2 -o .\Output\VirtualCom.iic .\Output\VirtualCom.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Documents and Settings\prku\Desktop\UART Debug\
  group Source Group 1
    ./Source/: fw.c isr.c Virtual.c USBJmpTb.OBJ EZUSB.LIB DSCR.A51
